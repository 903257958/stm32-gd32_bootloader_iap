# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: ..\..\app;..\..\app\log;..\..\app\bootloader;..\..\bsp;..\..\driver;..\..\core\cmsis\core;..\..\core\cmsis\device;..\..\core\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../../app/: main.c
  group app/log
    ../../app/log/: log.c log.h
  group app/bootloader
    ../../app/bootloader/: boot_cmd.c boot_cmd.h boot_comm.c boot_comm.h boot_config.h boot_core.c boot_core.h boot_event.c boot_event.h boot_ext_flash.c boot_ext_flash.h boot_flash.c boot_flash.h boot_ota.c boot_ota.h boot_store.c boot_store.h boot_xmodem.c boot_xmodem.h
  group bsp
    ../../bsp/: bsp_common.c bsp_common.h bsp_console.c bsp_console.h bsp_delay.c bsp_delay.h bsp_eeprom.c bsp_eeprom.h bsp_ext_flash.c bsp_ext_flash.h bsp_flash.c bsp_flash.h bsp_i2c_bus.c bsp_i2c_bus.h
  group driver
    ../../driver/: drv_w25qx.h drv_w25qx.c drv_uart.h drv_uart.c drv_spi.h drv_spi.c drv_i2c_soft.h drv_i2c_soft.c drv_flash.h drv_flash.c drv_eeprom.h drv_eeprom.c drv_delay.h drv_delay.c
  group core/cmsis
    ../../core/cmsis/core/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
    ../../core/cmsis/device/: startup_stm32f40_41xxx.s stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c system_stm32f4xx.h
  group core/driver
    ../../core/driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
