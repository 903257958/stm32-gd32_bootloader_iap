# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: ..\..\app;..\..\app\log;..\..\app\bootloader;..\..\app\test;..\..\bsp;..\..\driver;..\..\core\cmsis\core;..\..\core\cmsis\device;..\..\core\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../../app/: main.c
  group app/log
    ../../app/log/: log.c log.h
  group app/bootloader
    ../../app/bootloader/: boot_cmd.c boot_cmd.h boot_comm.c boot_comm.h boot_config.h boot_core.c boot_core.h boot_event.c boot_event.h boot_ext_flash.c boot_ext_flash.h boot_store.c boot_store.h boot_xmodem.c boot_xmodem.h
  group app/test
    ../../app/test/: test_core.c test_core.h test_module.c test_module.h
  group bsp
    ../../bsp/: bsp_common.c bsp_common.h bsp_delay.c bsp_delay.h bsp_eeprom.c bsp_eeprom.h bsp_ext_flash.c bsp_ext_flash.h bsp_flash.c bsp_flash.h bsp_i2c_bus.c bsp_i2c_bus.h bsp_log.c bsp_log.h
  group driver
    ../../driver/: drv_delay.c drv_delay.h drv_eeprom.c drv_eeprom.h drv_flash.c drv_flash.h drv_i2c_soft.c drv_i2c_soft.h drv_spi.c drv_spi.h drv_uart.c drv_uart.h drv_w25qx.c drv_w25qx.h
  group core/cmsis
    ../../core/cmsis/core/: core_cm3.c core_cm3.h
    ../../core/cmsis/device/: startup_stm32f10x_md.s stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
  group core/driver
    ../../core/driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
